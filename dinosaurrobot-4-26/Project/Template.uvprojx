# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\Project;..\STM32F10x_FWLib\inc;..\HARDWAVE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWAVE\CAN;..\HARDWAVE\MOTOR;..\HARDWAVE\JOINTCODER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Project
    ./: main.c stm32f10x_it.c system_stm32f10x.c iwdg.c control.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_iwdg.c
  group HARDWARE
    ../HARDWAVE/LED/: led.c
    ../HARDWAVE/CAN/: can.c
    ../HARDWAVE/MOTOR/: motor.c
    ../HARDWAVE/JOINTCODER/: jointcoder.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
